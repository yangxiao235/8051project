# Keil uVision project 数字口腔测力计v0.2.uvproj, settings and files
target 数字口腔测力计v0.2 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 数字口腔测力计v0.2
  c flags: Optimize=8 SizeSpeed=1
  c include: .\stc_lib;..\数字口腔测力计v0.2
  group user
    ./: STARTUP.A51 buzzer.c key.c lcd1602.c main.c ntostr.c
  group stclib
    ./stc_lib/: ADC.c delay.c EEPROM.c timer.c
