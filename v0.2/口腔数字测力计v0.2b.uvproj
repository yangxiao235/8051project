# Keil uVision project 口腔数字测力计v0.2b.uvproj, settings and files
target b (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 口腔数字测力计v0.2b +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\stc_lib;..\b
  group user
    ./: STARTUP.A51 buzzer.c key.c lcd1602.c main.c ntostr.c
  group stdlib
    ../stc_lib/: ADC.c delay.c EEPROM.c timer.c
